# Keil uVision project SEN0593.uvprojx, settings and files
target SEN0593 (ARM-ADS)
  device: CS32L010 Chipsea
  pack: Chipsea.CS32L010_DFP.1.0.4
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x01000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SEN0593 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\Main;.\User;.\Device\HAL_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group main
    ./Main/: main.c
  group user
    ./User/: DFRobot_REG_Operation.c DFRobot_RTU_Parse.c DFRobot_RTU_Timer.c DFRobot_RTU_User.c cs32l010_hal_msp.c cs32l010_it.c log.c DFRobot_TCS3430.c
  group driver
    ./Device/HAL_Driver/src/: cs32l010_hal.c cs32l010_hal_adc.c cs32l010_hal_awk.c cs32l010_hal_basetim.c cs32l010_hal_beep.c cs32l010_hal_clktrim.c cs32l010_hal_cortex.c cs32l010_hal_crc.c cs32l010_hal_flash.c cs32l010_hal_gpio.c cs32l010_hal_i2c.c cs32l010_hal_iwdg.c cs32l010_hal_lptim.c cs32l010_hal_lpuart.c cs32l010_hal_lvd.c cs32l010_hal_owire.c cs32l010_hal_pca.c cs32l010_hal_pwr.c cs32l010_hal_rcc.c cs32l010_hal_rtc.c cs32l010_hal_spi.c cs32l010_hal_tim.c cs32l010_hal_uart.c cs32l010_hal_vc.c cs32l010_hal_wwdg.c
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, Device:Startup 1.0.0
